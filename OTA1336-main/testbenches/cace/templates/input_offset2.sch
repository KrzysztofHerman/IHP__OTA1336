** sch_path: OTA1336-main/testbenches/cace/templates/input_offset2.sch
* Open sourced under Apache 2.0 license
**.subckt input_offset2
x1 vdd net1 out inm inp vss OTA1336
Ibias net1 VSUB DC CACE{Ibias}
VVcm inp VSUB DC CACE{Vcm}
Vvss vss VSUB DC CACE{Vvss}
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vvdd vdd VSUB DC CACE{Vvdd}
RSUB VSUB GND 0.01 m=1
V1 inm VSUB 0
**** begin user architecture code

* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the amplifier under condition of static input

.include CACE{DUT_path}

.lib cornerMOSlv.lib CACE{corner}
.lib cornerCAP.lib cap_typ

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1



.control
dc V1 0.58 0.62 1u
meas dc Vin_at when out = 0.6
let voffset = (0.6 - Vin_at)
echo $&voffset  > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
