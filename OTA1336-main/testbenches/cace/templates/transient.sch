** sch_path: OTA1336-main/testbenches/cace/templates/transient.sch
* Open sourced under Apache 2.0 license
**.subckt transient
x1 vdd net1 out inn inp vss OTA1336
Ibias net1 VSUB DC CACE{Ibias}
VVdiff inp VSUB DC 0 PWL(0 0 100n 0 100.1n CACE{Vvdd})
Vvss vss VSUB DC CACE{Vvss}
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vvdd vdd VSUB DC CACE{Vvdd}
RSUB VSUB GND 0.01 m=1
Evdrv inn VSUB out VSUB 1.0
**** begin user architecture code

* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the amplifier under condition of static input

.include CACE{DUT_path}

.lib cornerMOSlv.lib CACE{corner}
.lib cornerCAP.lib cap_typ

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1



.control
* Step function applied at time 100ns, save transient data
tran 10n 500n
set wr_singlescale
wrdata CACE{simpath}/CACE{filename}_CACE{N}.data V(out) V(inp)
quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
