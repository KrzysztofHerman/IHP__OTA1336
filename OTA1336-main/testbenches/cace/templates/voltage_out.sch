** sch_path: OTA1336-main/testbenches/cace/templates/voltage_out.sch
* Open sourced under Apache 2.0 license
**.subckt voltage_out
x1 vdd net1 out inm inp vss OTA1336
Ibias net1 VSUB DC CACE{Ibias}
VVcm1 inm VSUB DC CACE{Vcm}
Vvss1 vss VSUB DC CACE{Vvss}
Rout1 out VSUB CACE{Rout} m=1
Cout1 out VSUB CACE{Cout} m=1
Vvdd1 vdd VSUB DC CACE{Vvdd}
RSUB1 VSUB GND 0.01 m=1
VVdiff1 inp inm DC CACE{Vdiff}
**** begin user architecture code

* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the amplifier under condition of static input

.include CACE{DUT_path}

.lib cornerMOSlv.lib CACE{corner}
.lib cornerCAP.lib cap_typ

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1



.control
** Find voltage output as a DC operating point.  Set input differential
** to some value for calculating Voh or Vol.
op
let vtest = V(out)
set wr_singlescale
echo $&vtest > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
