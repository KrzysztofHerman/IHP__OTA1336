** sch_path: OTA1336-main/testbenches/cace/templates/input_offset.sch
* Open sourced under Apache 2.0 license
**.subckt input_offset
x1 vdd net1 out inm net4 vss OTA1336
Ibias net1 VSUB DC CACE{Ibias}
VVcm inp VSUB DC CACE{Vcm}
Vvss vss VSUB DC CACE{Vvss}
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vvdd vdd VSUB DC CACE{Vvdd}
RSUB VSUB GND 0.01 m=1
E1 net3 VSUB net2 inp 1000
Rfb net3 inm 99.9k m=1
Cfb net2 net3 5u m=1
Rfb1 inm inp 100 m=1
Rfb2 out net2 99.9k m=1
Rfb3 net4 inp 100 m=1
**** begin user architecture code

* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the amplifier under condition of static input

.include CACE{DUT_path}

.lib cornerMOSlv.lib CACE{corner}
.lib cornerCAP.lib cap_typ

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1



.control
op
let voffset = (inp - inm)
echo $&voffset  > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
