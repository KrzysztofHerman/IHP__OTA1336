** sch_path: OTA1336-main/testbenches/cace/templates/slew_rise.sch
* Open sourced under Apache 2.0 license
**.subckt slew_rise
x1 vdd ena out inm inp vss OTA1336
Ibias ena VSUB DC CACE{Ibias}
VVdiff1 inp VSUB DC 0 PWL(0 0 100n 0 100.1n CACE{Vvdd})
Vvss1 vss VSUB DC CACE{Vvss}
Vvdd1 vdd VSUB DC CACE{Vvdd}
RSUB1 VSUB GND 0.01 m=1
Evdrv inm VSUB out VSUB 1.0
**** begin user architecture code

* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the amplifier under condition of static input

.include CACE{DUT_path}

.lib cornerMOSlv.lib CACE{corner}
.lib cornerCAP.lib cap_typ

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1



.control
* Step function applied at time 100ns, measure slew from transient data
tran 100n 10u
meas tran tlow when V(out)=0.5 CROSS=LAST
meas tran thigh when V(out)= CACE[CACE{Vvdd} - 0.5] CROSS=LAST
let vres = 2.0 / ($&thigh - $&tlow)
* vres2 is full-power bandwidth (fpbw)
let vres2 = $&vres / (3.1415926 * CACE{Vvdd})

set wr_singlescale
echo $&vres $&vres2 > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc



.control
* Step function applied at time 100ns, measure slew from transient data
tran 100n 10u
meas tran thigh when V(out)= CACE[CACE{Vvdd} - 0.5] CROSS=LAST
meas tran tlow when V(out)=0.5 CROSS=LAST
let vres = 2.0 / ($&tlow - $&thigh)
* vres2 is the full-power bandwidth (fpbw)
let vres2 = $&vres / (3.1415926 * CACE{Vvdd})

echo $&vres $&vres2 > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
